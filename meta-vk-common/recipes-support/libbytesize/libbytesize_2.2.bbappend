#SRC_URI = "git://github.com/rhinstaller/libbytesize;branch=master;protocol=https"
SRC_URI = "git://github.com/storaged-project/libbytesize.git;branch=main"
