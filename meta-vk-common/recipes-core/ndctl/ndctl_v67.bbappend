#SRC_URI = "git://github.com/pmem/ndctl.git;branch=master;protocol=https"
SRC_URI = "git://github.com/pmem/ndctl.git;protocol=https;nobranch=1"
