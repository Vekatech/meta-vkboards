FILESEXTRAPATHS_prepend := "${THISDIR}/Kconfigs:"

SRC_URI_append = " \
	file://UDMABUF.cfg \
"

