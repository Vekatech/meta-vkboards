# Add our custom machine to the compatibility regex
COMPATIBLE_MACHINE:append = "|vkcmg2l|vkrzg2l"

