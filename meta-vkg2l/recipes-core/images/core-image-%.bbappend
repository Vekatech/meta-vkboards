#require conf/machine/include/core-image-sdk.inc
require recipes-core/images/include/extend_packages.inc

